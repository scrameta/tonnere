# Repository scrameta/tonnere (continued)

## KiCad design board/kicad/tonnere/tonnere.kicad_pcb (continued)

Schematic: cycloneve.kicad_sch

Parts:
C69, C71, C73, C74, C75, C76, C78, C82, C87, C89, C91, C92, C97, C100, C102, C117: 0.1uF; C_0603_1608Metric; LCSC C14663
C114: 10nF; C_0603_1608Metric; LCSC C57112
FB4, FB6: 70@100MHz; L_0805_2012Metric; LCSC C1012
J14: SPI CFG; PinSocket_2x03_P2.54mm_Vertical; LCSC C225518
J16: SPI SEL; PinHeader_1x03_P2.54mm_Vertical; LCSC C49257
J21: FPGA JTAG; IDC-Header_2x05_P2.54mm_Vertical; LCSC C5665
R73, R77, R78, R79, R82, R94, R96, R97, R113: 10k; R_0603_1608Metric; LCSC C25804
R80, R83, R86, R90, R91, R115, R118, R121, R125: 22; R_0603_1608Metric; LCSC C23345
R87, R88, R124, R126: 4k7; R_0603_1608Metric; LCSC C23162
R92: 2k7; R_0603_1608Metric; LCSC C13167
R99: 1k; R_0603_1608Metric; LCSC C21190
U28, U30: M25PX32-VMW; SOIC-8_5.3x6.2mm_P1.27mm; LCSC C2944643
U34: 10CL040f484; FBGA484_WIREBOND_A-2.40_INT; LCSC C1521940
Y4, Y7: 25MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC C337661
Y5, Y8: Si5351A-B-GT; MSOP-10_3x3mm_P0.5mm; LCSC C504891
Y6: ASE-27MHz; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm; LCSC C37635418

Connections:
+1V2: C73.1, C82.1, C91.1, C92.1, U34.E17 (VCCD_PLL[4]), U34.F6 (VCCD_PLL[4]), U34.G12 (VCCINT[28]), U34.H9 (VCCINT[28]), U34.J10 (VCCINT[28]), U34.J11 (VCCINT[28]), U34.J12 (VCCINT[28]), U34.J13 (VCCINT[28]), U34.J14 (VCCINT[28]), U34.J16 (VCCINT[28]), U34.K9 (VCCINT[28]), U34.K14 (VCCINT[28]), U34.K15 (VCCINT[28]), U34.L9 (VCCINT[28]), U34.L14 (VCCINT[28]), U34.L16 (VCCINT[28]), U34.M9 (VCCINT[28]), U34.M14 (VCCINT[28]), U34.M15 (VCCINT[28]), U34.N9 (VCCINT[28]), U34.N14 (VCCINT[28]), U34.P9 (VCCINT[28]), U34.P10 (VCCINT[28]), U34.P11 (VCCINT[28]), U34.P12 (VCCINT[28]), U34.P13 (VCCINT[28]), U34.P14 (VCCINT[28]), U34.R8 (VCCINT[28]), U34.R10 (VCCINT[28]), U34.R12 (VCCINT[28]), U34.U6 (VCCD_PLL[4]), U34.V17 (VCCD_PLL[4]); also elsewhere on the board
+2V5: C102.1, R92.2, R96.1, R97.1, U34.F18 (VCCA[4]), U34.G6 (VCCA[4]), U34.T6 (VCCA[4]), U34.U18 (VCCA[4]); also elsewhere on the board
+3V3: C69.1, C74.1, C75.1, C76.1, C78.1, C87.1, C89.1, C97.1, C100.1, C114.2, FB4.1, FB6.1, J14.1, J21.4, R73.2, R77.2, R78.1, R79.1, R82.1, R87.1, R88.1, R94.1, R113.2, R124.1, R126.1, U28.8 (V_{CC}), U30.8 (V_{CC}), U34.A2 (VCCIO8[5]), U34.A21 (VCCIO7[5]), U34.AA6 (VCCIO3[5]), U34.AB2 (VCCIO3[5]), U34.AB21 (VCCIO4[5]), U34.D4 (VCCIO1[4]), U34.D5 (VCCIO8[5]), U34.D9 (VCCIO8[5]), U34.D11 (VCCIO8[5]), U34.D12 (VCCIO7[5]), U34.D14 (VCCIO7[5]), U34.D16 (VCCIO7[5]), U34.D18 (VCCIO7[5]), U34.E8 (VCCIO8[5]), U34.E19 (VCCIO6[4]), U34.F4 (VCCIO1[4]), U34.G19 (VCCIO6[4]), U34.H4 (VCCIO1[4]), U34.J20 (VCCIO6[4]), U34.K4 (VCCIO1[4]), U34.L19 (VCCIO6[4]), U34.N4 (VCCIO2[4]), U34.P18 (VCCIO5[4]), U34.R4 (VCCIO2[4]), U34.T19 (VCCIO5[4]), U34.U4 (VCCIO2[4]), U34.V19 (VCCIO5[4]), U34.W4 (VCCIO2[4]), U34.W5 (VCCIO3[5]), U34.W9 (VCCIO3[5]), U34.W11 (VCCIO3[5]), U34.W12 (VCCIO4[5]), U34.W16 (VCCIO4[5]), U34.W18 (VCCIO4[5]), U34.Y14 (VCCIO4[5]), U34.Y19 (VCCIO5[4]), Y6.1 (EN), Y6.4 (Vdd); also elsewhere on the board
+3V3_SI53A: C71.1, FB4.2, Y5.1 (VDD), Y5.7 (VDDO)
+3V3_SI53B: C117.1, FB6.2, Y8.1 (VDD), Y8.7 (VDDO)
/AtariInterfaces/CONSOL.OPTION: U34.R6 (IO); also elsewhere on the board
/AtariInterfaces/CONSOL.RESET: U34.R7 (IO); also elsewhere on the board
/AtariInterfaces/CONSOL.SELECT: U34.R5 (IO); also elsewhere on the board
/AtariInterfaces/CONSOL.START: U34.T3 (IO); also elsewhere on the board
/AtariInterfaces/FPGA.GPIO0: U34.G7 (IO); also elsewhere on the board
/AtariInterfaces/FPGA.GPIO1: U34.J8 (DIFFIO_L14n); also elsewhere on the board
/AtariInterfaces/FPGA.GPIO2: U34.H8 (DIFFIO_L14p); also elsewhere on the board
/AtariInterfaces/FPGA.GPIO3: U34.K8 (DIFFIO_L20n); also elsewhere on the board
/AtariInterfaces/FPGA.GPIO4: U34.L8 (DIFFIO_L20p); also elsewhere on the board
/AtariInterfaces/JOY2.DIR8: U34.N5 (IO); also elsewhere on the board
/AtariInterfaces/JOY2.DIR9: U34.M5 (IO); also elsewhere on the board
/AtariInterfaces/JOY2.DIR10: U34.M4 (IO); also elsewhere on the board
/AtariInterfaces/JOY2.DIR11: U34.M7 (IO); also elsewhere on the board
/AtariInterfaces/JOY2.DIR12: U34.L7 (IO); also elsewhere on the board
/AtariInterfaces/JOY2.DIR13: U34.M1 (IO); also elsewhere on the board
/AtariInterfaces/JOY2.DIR14: U34.M2 (IO); also elsewhere on the board
/AtariInterfaces/JOY2.DIR15: U34.M3 (IO); also elsewhere on the board
/AtariInterfaces/JOY2.TRIG2: U34.L6 (IO); also elsewhere on the board
/AtariInterfaces/JOY2.TRIG3: U34.M8 (IO); also elsewhere on the board
/AtariInterfaces/JOY.DIR0: U34.P3 (IO); also elsewhere on the board
/AtariInterfaces/JOY.DIR1: U34.P1 (IO); also elsewhere on the board
/AtariInterfaces/JOY.DIR2: U34.P2 (IO); also elsewhere on the board
/AtariInterfaces/JOY.DIR3: U34.P4 (IO); also elsewhere on the board
/AtariInterfaces/JOY.DIR4: U34.N2 (IO); also elsewhere on the board
/AtariInterfaces/JOY.DIR5: U34.N8 (IO); also elsewhere on the board
/AtariInterfaces/JOY.DIR6: U34.N1 (IO); also elsewhere on the board
/AtariInterfaces/JOY.DIR7: U34.P7 (IO); also elsewhere on the board
/AtariInterfaces/JOY.TRIG0: U34.N6 (IO); also elsewhere on the board
/AtariInterfaces/JOY.TRIG1: U34.M6 (IO); also elsewhere on the board
/AtariInterfaces/PBI.A0: U34.C15 (IO); also elsewhere on the board
/AtariInterfaces/PBI.A1: U34.B15 (IO); also elsewhere on the board
/AtariInterfaces/PBI.A2: U34.H14 (IO); also elsewhere on the board
/AtariInterfaces/PBI.A3: U34.A15 (IO); also elsewhere on the board
/AtariInterfaces/PBI.A4: U34.D15 (IO); also elsewhere on the board
/AtariInterfaces/PBI.A5: U34.E15 (IO); also elsewhere on the board
/AtariInterfaces/PBI.A6: U34.F16 (IO); also elsewhere on the board
/AtariInterfaces/PBI.A7: U34.E16 (IO); also elsewhere on the board
/AtariInterfaces/PBI.A8: U34.F15 (IO); also elsewhere on the board
/AtariInterfaces/PBI.A9: U34.A16 (IO); also elsewhere on the board
/AtariInterfaces/PBI.A10: U34.B16 (IO); also elsewhere on the board
/AtariInterfaces/PBI.A11: U34.G16 (IO); also elsewhere on the board
/AtariInterfaces/PBI.A12: U34.D17 (IO); also elsewhere on the board
/AtariInterfaces/PBI.A13: U34.A17 (IO); also elsewhere on the board
/AtariInterfaces/PBI.A14: U34.B17 (IO); also elsewhere on the board
/AtariInterfaces/PBI.A15: U34.C17 (IO); also elsewhere on the board
/AtariInterfaces/PBI.CAS: U34.D20 (IO); also elsewhere on the board
/AtariInterfaces/PBI.CCTL: U34.H19 (IO); also elsewhere on the board
/AtariInterfaces/PBI.D0: U34.A18 (IO); also elsewhere on the board
/AtariInterfaces/PBI.D1: U34.B18 (IO); also elsewhere on the board
/AtariInterfaces/PBI.D1XX: U34.G18 (IO); also elsewhere on the board
/AtariInterfaces/PBI.D2: U34.D19 (IO); also elsewhere on the board
/AtariInterfaces/PBI.D3: U34.A19 (IO); also elsewhere on the board
/AtariInterfaces/PBI.D4: U34.B19 (IO); also elsewhere on the board
/AtariInterfaces/PBI.D5: U34.C19 (IO); also elsewhere on the board
/AtariInterfaces/PBI.D6: U34.A20 (IO); also elsewhere on the board
/AtariInterfaces/PBI.D7: U34.B20 (IO); also elsewhere on the board
/AtariInterfaces/PBI.EXTENB: U34.C22 (IO); also elsewhere on the board
/AtariInterfaces/PBI.EXTSEL: U34.B22 (IO); also elsewhere on the board
/AtariInterfaces/PBI.HALT: U34.C20 (IO); also elsewhere on the board
/AtariInterfaces/PBI.IRQ: U34.F19 (IO); also elsewhere on the board
/AtariInterfaces/PBI.MPD: U34.C21 (IO); also elsewhere on the board
/AtariInterfaces/PBI.PHI2: U34.B21 (IO); also elsewhere on the board
/AtariInterfaces/PBI.RAS: U34.H18 (IO); also elsewhere on the board
/AtariInterfaces/PBI.RD4: U34.D21 (IO); also elsewhere on the board
/AtariInterfaces/PBI.RD5: U34.H16 (IO); also elsewhere on the board
/AtariInterfaces/PBI.RDY: U34.E21 (IO); also elsewhere on the board
/AtariInterfaces/PBI.REF: U34.H17 (IO); also elsewhere on the board
/AtariInterfaces/PBI.RST: U34.G17 (IO); also elsewhere on the board
/AtariInterfaces/PBI.RW_N: U34.F17 (IO); also elsewhere on the board
/AtariInterfaces/PBI.S4_N: U34.D22 (IO); also elsewhere on the board
/AtariInterfaces/PBI.S5_N: U34.J17 (IO); also elsewhere on the board
/AtariInterfaces/SIO.CLOCK_IN: U34.F21 (IO); also elsewhere on the board
/AtariInterfaces/SIO.CLOCK_OUT: U34.F22 (IO); also elsewhere on the board
/AtariInterfaces/SIO.COMMAND: U34.F20 (IO); also elsewhere on the board
/AtariInterfaces/SIO.DATA_IN: U34.E22 (IO); also elsewhere on the board
/AtariInterfaces/SIO.DATA_OUT: U34.K18 (IO); also elsewhere on the board
/AtariInterfaces/SIO.INTERRUPT: U34.J22 (IO); also elsewhere on the board
/AtariInterfaces/SIO.MOTOR: U34.H20 (IO); also elsewhere on the board
/AtariInterfaces/SIO.PROCEED: U34.K17 (IO); also elsewhere on the board
/Audio/FPGAAUD.BCK: U34.B3 (IO); also elsewhere on the board
/Audio/FPGAAUD.DATA: U34.B4 (IO); also elsewhere on the board
/Audio/FPGAAUD.LR: U34.A4 (IO); also elsewhere on the board
/Audio/FPGAAUD.SPDIF: U34.H7 (IO); also elsewhere on the board
/ESP32/ESP.CS: U34.H21 (IO); also elsewhere on the board
/ESP32/ESP.MISO: U34.H22 (IO); also elsewhere on the board
/ESP32/ESP.MOSI: U34.J21 (IO); also elsewhere on the board
/ESP32/ESP.SCK: U34.J18 (IO); also elsewhere on the board
/FPGA/FPGA.CONFIG_N: R73.1, U34.K5 (nCONFIG); also elsewhere on the board
/FPGA/FPGA.CONF_DONE: R113.1, U34.M18 (CONF_DONE); also elsewhere on the board
/FPGA/FPGA.IRQ: U34.A3 (IO); also elsewhere on the board
/FPGA/FPGA.PS_N: R92.1, U34.L18 (MSEL1); also elsewhere on the board
/FPGA/FPGA.STATUS_N: R77.1, U34.K6 (nSTATUS); also elsewhere on the board
/FPGA/FSMC.A0: U34.G8 (IO); also elsewhere on the board
/FPGA/FSMC.A1: U34.D7 (IO); also elsewhere on the board
/FPGA/FSMC.A2: U34.E7 (IO); also elsewhere on the board
/FPGA/FSMC.A3: U34.F7 (IO); also elsewhere on the board
/FPGA/FSMC.A4: U34.D6 (IO); also elsewhere on the board
/FPGA/FSMC.A5: U34.E6 (IO); also elsewhere on the board
/FPGA/FSMC.A6: U34.E5 (IO); also elsewhere on the board
/FPGA/FSMC.A7: U34.B5 (IO); also elsewhere on the board
/FPGA/FSMC.A8: U34.A5 (IO); also elsewhere on the board
/FPGA/FSMC.A9: U34.C6 (IO); also elsewhere on the board
/FPGA/FSMC.A10: U34.B6 (IO); also elsewhere on the board
/FPGA/FSMC.A11: U34.A6 (IO); also elsewhere on the board
/FPGA/FSMC.A12: U34.A13 (IO); also elsewhere on the board
/FPGA/FSMC.A13: U34.B13 (IO); also elsewhere on the board
/FPGA/FSMC.A14: U34.B14 (IO); also elsewhere on the board
/FPGA/FSMC.A15: U34.A14 (IO); also elsewhere on the board
/FPGA/FSMC.A16: U34.G11 (IO); also elsewhere on the board
/FPGA/FSMC.A17: U34.F11 (IO); also elsewhere on the board
/FPGA/FSMC.A18: U34.E11 (IO); also elsewhere on the board
/FPGA/FSMC.A19: U34.F10 (IO); also elsewhere on the board
/FPGA/FSMC.A20: U34.F9 (IO); also elsewhere on the board
/FPGA/FSMC.A21: U34.G9 (IO); also elsewhere on the board
/FPGA/FSMC.A22: U34.F8 (IO); also elsewhere on the board
/FPGA/FSMC.D0: U34.E12 (IO); also elsewhere on the board
/FPGA/FSMC.D1: U34.C13 (IO); also elsewhere on the board
/FPGA/FSMC.D2: U34.E14 (IO); also elsewhere on the board
/FPGA/FSMC.D3: U34.F14 (IO); also elsewhere on the board
/FPGA/FSMC.D4: U34.C7 (IO); also elsewhere on the board
/FPGA/FSMC.D5: U34.B7 (IO); also elsewhere on the board
/FPGA/FSMC.D6: U34.A7 (IO); also elsewhere on the board
/FPGA/FSMC.D7: U34.C8 (IO); also elsewhere on the board
/FPGA/FSMC.D8: U34.B8 (IO); also elsewhere on the board
/FPGA/FSMC.D9: U34.A8 (IO); also elsewhere on the board
/FPGA/FSMC.D10: U34.E9 (IO); also elsewhere on the board
/FPGA/FSMC.D11: U34.B9 (IO); also elsewhere on the board
/FPGA/FSMC.D12: U34.A9 (IO); also elsewhere on the board
/FPGA/FSMC.D13: U34.C10 (IO); also elsewhere on the board
/FPGA/FSMC.D14: U34.B10 (IO); also elsewhere on the board
/FPGA/FSMC.D15: U34.A10 (IO); also elsewhere on the board
/FPGA/FSMC.NBL0: U34.D10 (IO); also elsewhere on the board
/FPGA/FSMC.NBL1: U34.E10 (IO); also elsewhere on the board
/FPGA/FSMC.NE1: U34.H11 (IO); also elsewhere on the board
/FPGA/FSMC.NOE: U34.E13 (IO); also elsewhere on the board
/FPGA/FSMC.NWAIT: U34.F13 (IO); also elsewhere on the board
/FPGA/FSMC.NWE: U34.D13 (IO); also elsewhere on the board
/FPGA/HDMI.CKN: U34.AB3 (IO); also elsewhere on the board
/FPGA/HDMI.CKP: U34.AA3 (IO); also elsewhere on the board
/FPGA/HDMI.D0N: U34.V1 (IO); also elsewhere on the board
/FPGA/HDMI.D0P: U34.V2 (IO); also elsewhere on the board
/FPGA/HDMI.D1N: U34.W1 (IO); also elsewhere on the board
/FPGA/HDMI.D1P: U34.W2 (IO); also elsewhere on the board
/FPGA/HDMI.D2N: U34.Y1 (IO); also elsewhere on the board
/FPGA/HDMI.D2P: U34.Y2 (IO); also elsewhere on the board
/FPGA/Net-(J17-Pin_1): J16.1, R94.2, U30.1 (~S/~CS)
/FPGA/Net-(J17-Pin_3): J16.3, R82.2, U28.1 (~S)
/FPGA/Net-(U27-DQ1): R80.1, U28.2 (DQ1)
/FPGA/Net-(U27-~HOLD): R79.2, U28.7 (~HOLD), U30.7 (~HOLD)
/FPGA/Net-(U27-~W/V_{PP}): R78.2, U28.3 (~W/V_{PP}), U30.3 (~W/V_{PP})
/FPGA/Net-(U29-DQ1/SO): R91.1, U30.2 (DQ1/SO)
/FPGA/Net-(U33J-CLK2): R86.2, U34.T2 (CLK2)
/FPGA/Net-(U33J-CLK3): R83.2, U34.T1 (CLK3)
/FPGA/Net-(U33J-CLK4): R125.2, U34.G21 (CLK4)
/FPGA/Net-(U33J-CLK5): R121.2, U34.G22 (CLK5)
/FPGA/Net-(U33J-CLK6): R118.2, U34.T21 (CLK6)
/FPGA/Net-(U33J-CLK8): R115.2, U34.A12 (CLK8)
/FPGA/Net-(U33J-CLK14): R90.2, U34.AB11 (CLK14)
/FPGA/PLL.SCL1: R87.2, Y5.4 (SCL); also elsewhere on the board
/FPGA/PLL.SCL2: R126.2, Y8.4 (SCL); also elsewhere on the board
/FPGA/PLL.SDA1: R88.2, Y5.5 (SDA); also elsewhere on the board
/FPGA/PLL.SDA2: R124.2, Y8.5 (SDA); also elsewhere on the board
/FPGA/SDRAM1.A0: U34.W20 (IO); also elsewhere on the board
/FPGA/SDRAM1.A1: U34.W21 (IO); also elsewhere on the board
/FPGA/SDRAM1.A2: U34.W22 (IO); also elsewhere on the board
/FPGA/SDRAM1.A3: U34.W19 (IO); also elsewhere on the board
/FPGA/SDRAM1.A4: U34.T17 (IO); also elsewhere on the board
/FPGA/SDRAM1.A5: U34.R18 (IO); also elsewhere on the board
/FPGA/SDRAM1.A6: U34.R19 (IO); also elsewhere on the board
/FPGA/SDRAM1.A7: U34.R17 (IO); also elsewhere on the board
/FPGA/SDRAM1.A8: U34.P17 (IO); also elsewhere on the board
/FPGA/SDRAM1.A9: U34.N16 (IO); also elsewhere on the board
/FPGA/SDRAM1.A10: U34.V22 (IO); also elsewhere on the board
/FPGA/SDRAM1.A11: U34.N17 (IO); also elsewhere on the board
/FPGA/SDRAM1.A12: U34.N19 (IO); also elsewhere on the board
/FPGA/SDRAM1.BA0: U34.U21 (IO); also elsewhere on the board
/FPGA/SDRAM1.BA1: U34.V21 (IO); also elsewhere on the board
/FPGA/SDRAM1.CAS_N: U34.U19 (IO); also elsewhere on the board
/FPGA/SDRAM1.CKE: U34.N18 (IO); also elsewhere on the board
/FPGA/SDRAM1.CLK: U34.R16 (IO); also elsewhere on the board
/FPGA/SDRAM1.CS_N: U34.U22 (IO); also elsewhere on the board
/FPGA/SDRAM1.DQ0: U34.N20 (IO); also elsewhere on the board
/FPGA/SDRAM1.DQ1: U34.N21 (IO); also elsewhere on the board
/FPGA/SDRAM1.DQ2: U34.N22 (IO); also elsewhere on the board
/FPGA/SDRAM1.DQ3: U34.P20 (IO); also elsewhere on the board
/FPGA/SDRAM1.DQ4: U34.P21 (IO); also elsewhere on the board
/FPGA/SDRAM1.DQ5: U34.P22 (IO); also elsewhere on the board
/FPGA/SDRAM1.DQ6: U34.R20 (IO); also elsewhere on the board
/FPGA/SDRAM1.DQ7: U34.R21 (IO); also elsewhere on the board
/FPGA/SDRAM1.DQ8: U34.M22 (IO); also elsewhere on the board
/FPGA/SDRAM1.DQ9: U34.M21 (IO); also elsewhere on the board
/FPGA/SDRAM1.DQ10: U34.M20 (IO); also elsewhere on the board
/FPGA/SDRAM1.DQ11: U34.L22 (IO); also elsewhere on the board
/FPGA/SDRAM1.DQ12: U34.L21 (IO); also elsewhere on the board
/FPGA/SDRAM1.DQ13: U34.K21 (IO); also elsewhere on the board
/FPGA/SDRAM1.DQ14: U34.K22 (IO); also elsewhere on the board
/FPGA/SDRAM1.DQ15: U34.K19 (IO); also elsewhere on the board
/FPGA/SDRAM1.LDQM: U34.R22 (IO); also elsewhere on the board
/FPGA/SDRAM1.RAS_N: U34.U20 (IO); also elsewhere on the board
/FPGA/SDRAM1.UDQM: U34.M19 (IO); also elsewhere on the board
/FPGA/SDRAM1.WE_N: U34.T18 (IO); also elsewhere on the board
/FPGA/SPI.CS2: J14.6, J16.2, U34.E2 (FLASH_nCE,nCSO); also elsewhere on the board
/FPGA/SPI.MISO: J14.3, R80.2, R91.2, U34.K1 (DATA0); also elsewhere on the board
/FPGA/SPI.MOSI: J14.4, U28.5 (DQ0), U30.5 (DQ0/SI), U34.D1 (DATA1,ASDO); also elsewhere on the board
/FPGA/SPI.SCK: J14.5, U28.6 (C), U30.6 (C/CLK), U34.K2 (DCLK); also elsewhere on the board
/FPGA/SRAM1.A0: U34.T5 (IO); also elsewhere on the board
/FPGA/SRAM1.A1: U34.Y4 (IO); also elsewhere on the board
/FPGA/SRAM1.A2: U34.AA4 (IO); also elsewhere on the board
/FPGA/SRAM1.A3: U34.Y3 (IO); also elsewhere on the board
/FPGA/SRAM1.A4: U34.V4 (IO); also elsewhere on the board
/FPGA/SRAM1.A5: U34.W8 (IO); also elsewhere on the board
/FPGA/SRAM1.A6: U34.T9 (IO); also elsewhere on the board
/FPGA/SRAM1.A7: U34.U10 (IO); also elsewhere on the board
/FPGA/SRAM1.A8: U34.AA9 (IO); also elsewhere on the board
/FPGA/SRAM1.A9: U34.AB8 (IO); also elsewhere on the board
/FPGA/SRAM1.A10: U34.Y8 (IO); also elsewhere on the board
/FPGA/SRAM1.A11: U34.AB7 (IO); also elsewhere on the board
/FPGA/SRAM1.A12: U34.V9 (IO); also elsewhere on the board
/FPGA/SRAM1.A13: U34.AA8 (IO); also elsewhere on the board
/FPGA/SRAM1.A14: U34.T11 (IO); also elsewhere on the board
/FPGA/SRAM1.A15: U34.W10 (IO); also elsewhere on the board
/FPGA/SRAM1.A16: U34.V10 (IO); also elsewhere on the board
/FPGA/SRAM1.A17: U34.U9 (IO); also elsewhere on the board
/FPGA/SRAM1.A18: U34.Y10 (IO); also elsewhere on the board
/FPGA/SRAM1.A19: U34.AB9 (IO); also elsewhere on the board
/FPGA/SRAM1.A20: U34.AA7 (IO); also elsewhere on the board
/FPGA/SRAM1.CE_N: U34.W6 (IO); also elsewhere on the board
/FPGA/SRAM1.D0: U34.AB4 (IO); also elsewhere on the board
/FPGA/SRAM1.D1: U34.T7 (IO); also elsewhere on the board
/FPGA/SRAM1.D2: U34.V6 (IO); also elsewhere on the board
/FPGA/SRAM1.D3: U34.U7 (IO); also elsewhere on the board
/FPGA/SRAM1.D4: U34.AA5 (IO); also elsewhere on the board
/FPGA/SRAM1.D5: U34.Y6 (IO); also elsewhere on the board
/FPGA/SRAM1.D6: U34.AB5 (IO); also elsewhere on the board
/FPGA/SRAM1.D7: U34.Y7 (IO); also elsewhere on the board
/FPGA/SRAM1.D8: U34.W7 (IO); also elsewhere on the board
/FPGA/SRAM1.D9: U34.U8 (IO); also elsewhere on the board
/FPGA/SRAM1.D10: U34.V8 (IO); also elsewhere on the board
/FPGA/SRAM1.D11: U34.V3 (IO); also elsewhere on the board
/FPGA/SRAM1.D12: U34.V11 (IO); also elsewhere on the board
/FPGA/SRAM1.D13: U34.AB10 (IO); also elsewhere on the board
/FPGA/SRAM1.D14: U34.U11 (IO); also elsewhere on the board
/FPGA/SRAM1.D15: U34.AA10 (IO); also elsewhere on the board
/FPGA/SRAM1.LB_N: U34.V7 (IO); also elsewhere on the board
/FPGA/SRAM1.OE_N: U34.T4 (IO); also elsewhere on the board
/FPGA/SRAM1.UB_N: U34.V5 (IO); also elsewhere on the board
/FPGA/SRAM1.W_N: U34.T8 (IO); also elsewhere on the board
/FPGA/SRAM2.A0: U34.V13 (IO); also elsewhere on the board
/FPGA/SRAM2.A1: U34.AB14 (IO); also elsewhere on the board
/FPGA/SRAM2.A2: U34.W15 (IO); also elsewhere on the board
/FPGA/SRAM2.A3: U34.AA14 (IO); also elsewhere on the board
/FPGA/SRAM2.A4: U34.R14 (IO); also elsewhere on the board
/FPGA/SRAM2.A5: U34.U12 (IO); also elsewhere on the board
/FPGA/SRAM2.A6: U34.U13 (IO); also elsewhere on the board
/FPGA/SRAM2.A7: U34.V15 (IO); also elsewhere on the board
/FPGA/SRAM2.A8: U34.AA20 (IO); also elsewhere on the board
/FPGA/SRAM2.A9: U34.AA19 (IO); also elsewhere on the board
/FPGA/SRAM2.A10: U34.AB18 (IO); also elsewhere on the board
/FPGA/SRAM2.A11: U34.Y17 (IO); also elsewhere on the board
/FPGA/SRAM2.A12: U34.AA18 (IO); also elsewhere on the board
/FPGA/SRAM2.A13: U34.W17 (IO); also elsewhere on the board
/FPGA/SRAM2.A14: U34.U16 (IO); also elsewhere on the board
/FPGA/SRAM2.A15: U34.T16 (IO); also elsewhere on the board
/FPGA/SRAM2.A16: U34.R15 (IO); also elsewhere on the board
/FPGA/SRAM2.A17: U34.U15 (IO); also elsewhere on the board
/FPGA/SRAM2.A18: U34.Y21 (IO); also elsewhere on the board
/FPGA/SRAM2.A19: U34.AB19 (IO); also elsewhere on the board
/FPGA/SRAM2.A20: U34.U17 (IO); also elsewhere on the board
/FPGA/SRAM2.CE_N: U34.W13 (IO); also elsewhere on the board
/FPGA/SRAM2.D0: U34.T14 (IO); also elsewhere on the board
/FPGA/SRAM2.D1: U34.U14 (IO); also elsewhere on the board
/FPGA/SRAM2.D2: U34.V14 (IO); also elsewhere on the board
/FPGA/SRAM2.D3: U34.T15 (IO); also elsewhere on the board
/FPGA/SRAM2.D4: U34.AB15 (IO); also elsewhere on the board
/FPGA/SRAM2.D5: U34.V16 (IO); also elsewhere on the board
/FPGA/SRAM2.D6: U34.AA15 (IO); also elsewhere on the board
/FPGA/SRAM2.D7: U34.AB16 (IO); also elsewhere on the board
/FPGA/SRAM2.D8: U34.AA13 (IO); also elsewhere on the board
/FPGA/SRAM2.D9: U34.T13 (IO); also elsewhere on the board
/FPGA/SRAM2.D10: U34.Y13 (IO); also elsewhere on the board
/FPGA/SRAM2.D11: U34.V12 (IO); also elsewhere on the board
/FPGA/SRAM2.D12: U34.Y22 (IO); also elsewhere on the board
/FPGA/SRAM2.D13: U34.AA21 (IO); also elsewhere on the board
/FPGA/SRAM2.D14: U34.AA22 (IO); also elsewhere on the board
/FPGA/SRAM2.D15: U34.AB20 (IO); also elsewhere on the board
/FPGA/SRAM2.LB_N: U34.T12 (IO); also elsewhere on the board
/FPGA/SRAM2.OE_N: U34.AB13 (IO); also elsewhere on the board
/FPGA/SRAM2.UB_N: U34.W14 (IO); also elsewhere on the board
/FPGA/SRAM2.W_N: U34.AA16 (IO); also elsewhere on the board
/FPGA/TCK: J21.1, R99.1, U34.L2 (TCK)
/FPGA/TDI: J21.9, R96.2, U34.L5 (TDI)
/FPGA/TDO: J21.3, U34.L4 (TDO)
/FPGA/TMS: J21.5, R97.2, U34.L1 (TMS)
/FPGA/VDAC.B0: U34.B1 (DIFFIO_L2n); also elsewhere on the board
/FPGA/VDAC.B1: U34.B2 (DIFFIO_L2p); also elsewhere on the board
/FPGA/VDAC.B2: U34.C3 (IO); also elsewhere on the board
/FPGA/VDAC.B3: U34.C4 (IO); also elsewhere on the board
/FPGA/VDAC.B4: U34.D2 (DIFFIO_L8p); also elsewhere on the board
/FPGA/VDAC.B5: U34.E4 (DIFFIO_L4p); also elsewhere on the board
/FPGA/VDAC.G0: U34.E1 (DIFFIO_L10n); also elsewhere on the board
/FPGA/VDAC.G1: U34.E3 (DIFFIO_L4n); also elsewhere on the board
/FPGA/VDAC.G2: U34.G4 (DIFFIO_L1p); also elsewhere on the board
/FPGA/VDAC.G3: U34.G5 (IO); also elsewhere on the board
/FPGA/VDAC.G4: U34.H6 (DIFFIO_L9p); also elsewhere on the board
/FPGA/VDAC.G5: U34.H5 (IO); also elsewhere on the board
/FPGA/VDAC.HSYNC: U34.R2 (IO); also elsewhere on the board
/FPGA/VDAC.R0: U34.G3 (DIFFIO_L1n); also elsewhere on the board
/FPGA/VDAC.R1: U34.F2 (DIFFIO_L12p); also elsewhere on the board
/FPGA/VDAC.R2: U34.F1 (DIFFIO_L12n); also elsewhere on the board
/FPGA/VDAC.R3: U34.J3 (IO); also elsewhere on the board
/FPGA/VDAC.R4: U34.H2 (DIFFIO_L23p); also elsewhere on the board
/FPGA/VDAC.R5: U34.H1 (DIFFIO_L23n); also elsewhere on the board
/FPGA/VDAC.VSYNC: U34.R1 (IO); also elsewhere on the board
/FPGA/unconnected-(J22-Pin_6-Pad6): J21.6
/FPGA/unconnected-(J22-Pin_7-Pad7): J21.7
/FPGA/unconnected-(J22-Pin_8-Pad8): J21.8
/FPGA/unconnected-(U33A-DIFFIO_L9n-PadJ6): U34.J6 (DIFFIO_L9n)
/FPGA/unconnected-(U33A-DIFFIO_L18n-PadJ5): U34.J5 (DIFFIO_L18n)
/FPGA/unconnected-(U33A-DIFFIO_L21p-PadJ7): U34.J7 (DIFFIO_L21p)
/FPGA/unconnected-(U33A-DIFFIO_L24n-PadJ1): U34.J1 (DIFFIO_L24n)
/FPGA/unconnected-(U33A-DIFFIO_L24p-PadJ2): U34.J2 (DIFFIO_L24p)
/FPGA/unconnected-(U33B-IO-PadN7): U34.N7 (IO)
/FPGA/unconnected-(U33B-IO-PadP5): U34.P5 (IO)
/FPGA/unconnected-(U33B-IO-PadP6): U34.P6 (IO)
/FPGA/unconnected-(U33B-IO-PadU1): U34.U1 (IO)
/FPGA/unconnected-(U33B-IO-PadU2): U34.U2 (IO)
/FPGA/unconnected-(U33C-IO-PadT10): U34.T10 (IO)
/FPGA/unconnected-(U33E-IO-PadM16): U34.M16 (IO)
/FPGA/unconnected-(U33E-IO-PadP15): U34.P15 (IO)
/FPGA/unconnected-(U33E-IO-PadP16): U34.P16 (IO)
/FPGA/unconnected-(U33G-IO-PadG13): U34.G13 (IO)
/FPGA/unconnected-(U33G-IO-PadG14): U34.G14 (IO)
/FPGA/unconnected-(U33G-IO-PadG15): U34.G15 (IO)
/FPGA/unconnected-(U33G-IO-PadH15): U34.H15 (IO)
/FPGA/unconnected-(U33H-IO-PadG10): U34.G10 (IO)
/FPGA/unconnected-(U33H-IO-PadH10): U34.H10 (IO)
/FPGA/unconnected-(U33bank1-DIFFIO_L21n-PadK7): U34.K7 (DIFFIO_L21n)
/FPGA/unconnected-(U33bank1-IO-PadJ4): U34.J4 (IO)
GND: C69.2, C71.2, C73.2, C74.2, C75.2, C76.2, C78.2, C82.2, C87.2, C89.2, C91.2, C92.2, C97.2, C100.2, C102.2, C114.1, C117.2, J14.2, J21.2, J21.10, R99.2, U28.4 (V_{SS}), U30.4 (V_{SS}), U34.A1 (GND[70]), U34.A11 (CLK10), U34.A22 (GND[70]), U34.AA1 (GND[70]), U34.AA2 (GND[70]), U34.AA11 (CLK15), U34.AA12 (CLK13), U34.AA17 (GND[70]), U34.AB1 (GND[70]), U34.AB6 (GND[70]), U34.AB12 (CLK12), U34.AB17 (GND[70]), U34.AB22 (GND[70]), U34.B11 (CLK11), U34.B12 (CLK9), U34.C1 (GND[70]), U34.C2 (GND[70]), U34.C5 (GND[70]), U34.C9 (GND[70]), U34.C11 (GND[70]), U34.C12 (GND[70]), U34.C14 (GND[70]), U34.C16 (GND[70]), U34.C18 (GND[70]), U34.D3 (GND[70]), U34.D8 (GND[70]), U34.E18 (GNDA[4]), U34.E20 (GND[70]), U34.F3 (GND[70]), U34.F5 (GNDA[4]), U34.F12 (GND[70]), U34.G1 (CLK1), U34.G2 (CLK0), U34.G20 (GND[70]), U34.H3 (GND[70]), U34.H12 (GND[70]), U34.H13 (GND[70]), U34.J9 (GND[70]), U34.J15 (GND[70]), U34.J19 (GND[70]), U34.K3 (GND[70]), U34.K10 (GND[70]), U34.K11 (GND[70]), U34.K12 (GND[70]), U34.K13 (GND[70]), U34.K16 (GND[70]), U34.K20 (MSEL3), U34.L3 (nCE), U34.L10 (GND[70]), U34.L11 (GND[70]), U34.L12 (GND[70]), U34.L13 (GND[70]), U34.L15 (GND[70]), U34.L17 (MSEL2), U34.L20 (GND[70]), U34.M10 (GND[70]), U34.M11 (GND[70]), U34.M12 (GND[70]), U34.M13 (GND[70]), U34.M17 (MSEL0), U34.N3 (GND[70]), U34.N10 (GND[70]), U34.N11 (GND[70]), U34.N12 (GND[70]), U34.N13 (GND[70]), U34.N15 (GND[70]), U34.P8 (GND[70]), U34.P19 (GND[70]), U34.R3 (GND[70]), U34.R9 (GND[70]), U34.R11 (GND[70]), U34.R13 (GND[70]), U34.T20 (GND[70]), U34.T22 (CLK7), U34.U3 (GND[70]), U34.U5 (GNDA[4]), U34.V18 (GNDA[4]), U34.V20 (GND[70]), U34.W3 (GND[70]), U34.Y5 (GND[70]), U34.Y9 (GND[70]), U34.Y11 (GND[70]), U34.Y12 (GND[70]), U34.Y15 (GND[70]), U34.Y16 (GND[70]), U34.Y18 (GND[70]), U34.Y20 (GND[70]), Y4.2, Y4.4, Y5.8 (GND), Y6.2 (GND), Y7.2, Y7.4, Y8.8 (GND); also elsewhere on the board
unnamed: R83.1, Y5.10 (CLK0)
unnamed: R86.1, Y5.9 (CLK1)
unnamed: R90.1, Y5.6 (CLK2)
unnamed: Y4.3, Y5.2 (XA)
unnamed: Y4.1, Y5.3 (XB)
unnamed: R115.1, Y6.3 (OUT)
unnamed: R118.1, Y8.10 (CLK0)
unnamed: R121.1, Y8.9 (CLK1)
unnamed: R125.1, Y8.6 (CLK2)
unnamed: Y7.3, Y8.2 (XA)
unnamed: Y7.1, Y8.3 (XB)

Notes on the sheet:
1:34 - pot 8, ADC 2 -> 10 taken, then jtag 2:44 - dir 8, trig 2, VDAC 28 -> 38, can also drive VDAC from bank 1 Available via middle layer if needed: Bank 1: 3 hard to route: J7,J8,L8 Bank 2: 3 hard to route: L7,M7,M8
3.3v: VCCIO1-8,SPI,5351,5351
6,8 or 10nF
2.5v: VCCA
Free
HDMI is here for p/n pairs
FPGACFG.SC_N
VCCIO1 for CONFIG_N VCCIO1 for STATUS_N
1.2v: VCCINTx4,VCCD_PLL
FPGACFG.FISO
Pull up to VCCA (not VCCIO)
VCCIO6 for CONF_DONE
FPGACFG.SCK
FPGACFG.FOSI
VCCA for MSEL
43+43 FSMC: 16+23+2+4 -> 45 PBI: 16+8+17 -> 41 Not room here...
83 vs 81 16+21+5 = 42 16+13+2+8 = 39 Likely to overflow a bit due to break out difficulty, clks Moved OE_N,CE_N,LB_N,UB_N to prior bank bank3: T8/T10 hard to route
42 vs 16+21+5 = 42 likely to overflow a bit due to breakout difficulty, clks and prior overflow. So assume both banks taken! Then 41 So, say we do ESP + HDMI -> 4+10 41-overflow-clks-14
CFG (do not count) ESP,4 FSMC,16+23+2+4 SRAM,16+21+5 SRAM,16+21+5 SDRAM,16+13+2+8 HDMI,8 VDAC,8+8+8+3+2 PBI,16+8+17 JOY,8+2+4*2
